# Repository mgosselin/gppr

## KiCad design cad/gppr.kicad_pcb

Parts:
C1, C2, C4: 10uF; C_1210_3225Metric
C3, C5, C10: 1uF; C_1206_3216Metric
C6, C7, C8, C9: 1000uF; CP_Elec_16x17.5
D1, D2, D3, D4: MURS120; D_SMB
D5: 1SMB5927BT3G; D_SMB
D6: LED_POWER; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965
HS1: Heatsink_Pad; Heatsink_960-23-XX-F-AB-0_Top
J1: Conn_01x04_Female; Molex_Micro-Fit_3.0_43045-0412_2x02_P3.00mm_Vertical
J2: Conn_01x02_Female; Molex_Micro-Fit_3.0_43045-0212_2x01_P3.00mm_Vertical
J3: Conn_Coaxial; U.FL_Molex_MCRF_73412-0110_Vertical
Q1: IRLR2908; TO-252-2
R1: 76.8KΩ; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 10.2KΩ; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 1KΩ; R_0805_2012Metric
R4: 13KΩ; R_0805_2012Metric
R5, R6: 0Ω; R_0805_2012Metric
TP1, TP2, TP3: TestPoint_2Pole; PinHeader_1x02_P2.54mm_Vertical
U1: TPS7A470X; Texas_VQFN-RGW-20

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D2.2 (A), D4.2 (A), D6.1 (K), HS1.1, J2.2, J3.2 (Ext), R2.1, TP1.2, TP2.2, TP3.2, U1.7 (GND), U1.17 (NC), U1.18 (NC), U1.19 (NC), U1.21 (PAD)
unnamed: C1.1, D5.1 (K), Q1.1 (G), R4.1
unnamed: C2.1, C3.1, R6.1, U1.13 (EN), U1.15 (IN), U1.16 (IN)
unnamed: C4.1, C5.1, J2.1, J3.1 (In), R1.2, R3.2, TP3.1, U1.1 (OUT), U1.20 (OUT)
unnamed: C6.1, C7.1, C8.1, C9.1, D1.1 (K), D3.1 (K), R5.2, TP1.1
unnamed: C10.1, U1.14 (NR)
unnamed: D1.2 (A), D2.1 (K), J1.2, J1.4
unnamed: D3.2 (A), D4.1 (K), J1.1, J1.3
unnamed: D5.2 (A), Q1.3 (S), R6.2, TP2.1
unnamed: D6.2 (A), R3.1
unnamed: Q1.2 (D), R4.2, R5.1
unnamed: R1.1, R2.2, U1.3 (SENSE/FB)

Notes on the sheet:
Capacitors: Panasonic EEV-FK1H102M

Board: 2 copper layers, 90.0 x 50.0 mm, 35 parts (0 on the bottom side), 12 nets.

## Commit log

2019-07-08 create complete schematic
2019-07-08 update schematic: remove any-out, use resistor-divider fb on regulator instead
2019-07-08 add missing footprint references for in/out connectors
2019-07-09 add simple calcs for max input voltage for safe operation
2019-07-10 generate netlist
2019-07-10 remove .bak and greate .kicad_pcb file
2019-07-10 un-track .DS_store
2019-07-10 remove .DS_store from /cad
2019-07-11 add jumper-resistors, change ceramic film capacitor packages
2019-07-17 basic component placement, prep for trace routing
2019-07-21 change heatsink footprint from bottom to top side
2019-07-22 reposition components, prep to route
2019-08-31 route the board
2019-08-31 generate gerber and drill files
